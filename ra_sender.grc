<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ra_sender</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>calstate</value></param>
<param><key>value</key><value>rsu.calib_onoff_auto(tick, cdev, 19200, cinit, con, coff, "\r", 3600,45)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>det_corrections</value></param>
<param><key>value</key><value>rsu.update_corrections(det_vecs)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>det_vecs</value></param>
<param><key>block_id</key><value>det_vec_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0.0,0.0]</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>devices</value></param>
<param><key>value</key><value>udev if udev !="None" else devid1+" "+devid2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>drate</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>pdfilt_1</value></param>
<param><key>cutoff_freq</key><value>dbw/2</value></param>
<param><key>gain</key><value>fg1</value></param>
<param><key>samp_rate</key><value>srate</value></param>
<param><key>width</key><value>srate/4.0</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>pdfilt_2</value></param>
<param><key>cutoff_freq</key><value>dbw/2</value></param>
<param><key>gain</key><value>fg2</value></param>
<param><key>samp_rate</key><value>srate</value></param>
<param><key>width</key><value>srate/4.0</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>srate</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tick</value></param>
<param><key>block_id</key><value>cal_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>abw</value></param>
<param><key>label</key><value>Analog bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-1</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0_0</value></param>
<param><key>addr</key><value>host</value></param>
<param><key>type</key><value>float</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>port</value></param>
<param><key>vlen</key><value>512</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0_0_0</value></param>
<param><key>addr</key><value>host</value></param>
<param><key>type</key><value>float</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>port+1</value></param>
<param><key>vlen</key><value>2048</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>1.0 if calstate == "ON" else 0.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>2048</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>5</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>int(srate/drate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>int(srate/drate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>20</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>2048</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1_0</value></param>
<param><key>n</key><value>20</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>2048</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>det_corrections[0]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>det_corrections[1]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>0.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>512</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>cal_probe</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cdev</value></param>
<param><key>label</key><value>Calib Device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/dev/ttyACM0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cinit</value></param>
<param><key>label</key><value>Calib in it string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"C,0,0,0,0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>coff</value></param>
<param><key>label</key><value>Calib OFF string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"O,0,0,0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>con</value></param>
<param><key>label</key><value>Calib ON string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"O,0,15,0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dbw</value></param>
<param><key>label</key><value>Detector Bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>det_vec_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid1</value></param>
<param><key>label</key><value>1st Device Id</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"rtl=RCVR1"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid2</value></param>
<param><key>label</key><value>2nd Device ID</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"rtl=RCVR2"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f1</value></param>
<param><key>label</key><value>Frequency Chan. 1</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1420.4058e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f2</value></param>
<param><key>label</key><value>Frequency Chan. 2</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1420.4058e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fg1</value></param>
<param><key>label</key><value>Filter 1 gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fg2</value></param>
<param><key>label</key><value>Filter 2 gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>pdfilt_1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>pdfilt_2</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>35</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>host</value></param>
<param><key>label</key><value>Target host IP address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>192.168.1.101</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import ra_sender_utils as rsu</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>1.0/(50*3)</value></param>
<param><key>average</key><value>True</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>frame_rate</key><value>100</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0_0</value></param>
<param><key>avg_alpha</key><value>1.0/(50*3)</value></param>
<param><key>average</key><value>True</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>frame_rate</key><value>100</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Stream used for pacing</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>samp_rate*0.85 if abw &lt; 0.0 else abw</value></param>
<param><key>freq0</key><value>f1</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>bb_gain1</key><value>20</value></param>
<param><key>bw1</key><value>samp_rate*0.85 if abw &lt; 0.0 else abw</value></param>
<param><key>dc_offset_mode1</key><value>0</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>f2</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>if_gain1</key><value>20</value></param>
<param><key>iq_balance_mode1</key><value>0</value></param>
<param><key>gain1</key><value>gain</value></param>
<param><key>args</key><value>devices</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>Target port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5551</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_1</value></param>
<param><key>alpha</key><value>1.0/(samp_rate/(drate/3))</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_1_0</value></param>
<param><key>alpha</key><value>1.0/(srate/(drate/3))</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.56e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udev</value></param>
<param><key>label</key><value>UHD Device string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"None"</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_interleave_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_interleave_1</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blks2_tcp_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_1</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>cal_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_interleave_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_interleave_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>blks2_tcp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>det_vec_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_interleave_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>logpwrfft_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_1</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_1_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
