<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>corrint_uhd</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>detect_rate</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>srate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tweaked_freq</value></param>
<param><key>value</key><value>uhd.tune_request(freq,samp_rate+100e3)</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>addr</key><value>host</value></param>
<param><key>type</key><value>float</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>port</value></param>
<param><key>vlen</key><value>5</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>int(samp_rate/detect_rate)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1.0e8</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock</value></param>
<param><key>label</key><value>Clock Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>32e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid</value></param>
<param><key>label</key><value>Device ID</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>type=b200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4.2e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain1</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>70</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain2</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>70</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>host</value></param>
<param><key>label</key><value>Target host</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>172.16.10.106</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>Target port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1420</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sargs</value></param>
<param><key>label</key><value>Stream Args</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"peak=0.00025"</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0/(samp_rate/10)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6.2e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subdev</value></param>
<param><key>label</key><value>Subdev Spec</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>A:A A:B</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain1</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>freq</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gain2</value></param>
<param><key>clock_rate</key><value>clock</value></param>
<param><key>dev_addr</key><value>devid</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>subdev</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>stream_args</key><value>sargs</value></param>
<param><key>sync</key><value></value></param>
<param><key>otw</key><value>sc8</value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
