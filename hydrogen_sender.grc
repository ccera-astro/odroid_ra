<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hydrogen_sender</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>devices</value></param>
<param><key>value</key><value>rsu.map_udev(udev) if udev !="None" else devid1+" "+devid2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>drate</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frate</value></param>
<param><key>value</key><value>75</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lpf_len</value></param>
<param><key>value</key><value>len(lpf_taps)</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lpf_taps</value></param>
<param><key>cutoff_freq</key><value>1.15e6</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>230e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>outrate</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>pdfilt_1</value></param>
<param><key>cutoff_freq</key><value>dbw/2</value></param>
<param><key>gain</key><value>fg1</value></param>
<param><key>samp_rate</key><value>srate</value></param>
<param><key>width</key><value>srate/4.0</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>pdfilt_2</value></param>
<param><key>cutoff_freq</key><value>dbw/2</value></param>
<param><key>gain</key><value>fg2</value></param>
<param><key>samp_rate</key><value>srate</value></param>
<param><key>width</key><value>srate/4.0</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>srate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>abw</value></param>
<param><key>label</key><value>RF front-end bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-1.0</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0_0_0</value></param>
<param><key>addr</key><value>host</value></param>
<param><key>type</key><value>float</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>port+1</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>int(2.5e6/fftsize/frate)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>int(frate/outrate)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cdev</value></param>
<param><key>label</key><value>Calib Device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/dev/ttyACM0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cinit</value></param>
<param><key>label</key><value>Calib in it string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"C,0,0,0,0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>coff</value></param>
<param><key>label</key><value>Calib OFF string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"O,0,0,0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>con</value></param>
<param><key>label</key><value>Calib ON string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"O,0,15,0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dbw</value></param>
<param><key>label</key><value>Detector Bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid1</value></param>
<param><key>label</key><value>1st Device Id</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"rtl=RCVR1"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid2</value></param>
<param><key>label</key><value>2nd Device ID</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"rtl=RCVR2"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f1</value></param>
<param><key>label</key><value>Frequency Chan. 1</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1420.4058e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f2</value></param>
<param><key>label</key><value>Frequency Chan. 2</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1420.4058e6</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate/2.5e6)</value></param>
<param><key>taps</key><value>lpf_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>2</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>window.blackmanharris(fftsize)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fg1</value></param>
<param><key>label</key><value>Filter 1 gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fg2</value></param>
<param><key>label</key><value>Filter 2 gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>35</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>host</value></param>
<param><key>label</key><value>Target host IP address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>192.168.1.101</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Stream used for pacing</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>f1</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>devices</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>Target port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5551</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>rsu</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
#
# Configuration management for Simple RA
#
# Marcus Leech, Science Radio Laboratories, Inc.
#
import os
import signal
import numpy
import math
import sys
import time
import serial
import stat

cal_ontime = 30
CAL_INIT_REQUIRED = 0
CAL_WAITING = 1
CAL_ON = 2
CAL_BADDEVICE = 3
CAL_MANUAL = 4
cal_state = CAL_WAITING
serh = None

def calib_onoff_auto(depvar, devname, baudrate, initstring, onstring, offstring, lterm, every, seconds):
    global serh
    global cal_state
    global cal_ontime
    global CAL_INIT_REQUIRED
    global CAL_WAITING
    global CAL_ON
    global CAL_BADDEVICE
    global CAL_MANUAL
    
    f = open ("/tmp/ra_sender.pid", "w")
    f.write(str(os.getpid())+"\n")
    f.close()

    if (os.path.exists(devname)):
        s = os.stat(devname)
        if stat.S_ISREG(s.st_mode):
            if (s.st_size &gt; 0):
                return "ON"
            else:
                return "OFF"
 
    #sys.stderr.write("Here I am"+"\n")

    if (cal_state == CAL_BADDEVICE):
        return "BAD-DEVICE"

    if (len(devname) == 0 or devname == "none"):
        return "OFF"

    if (cal_state == CAL_WAITING):
        t = int(time.time())
        f = t % int(every)
        if (f &lt;= 4) and serh == None:
            #sys.stderr.write( "transitioning to ON at %d\n" % t)
            try:
               serh = serial.Serial (devname, baudrate, timeout=0)
            except:
                cal_state = CAL_BADDEVICE
                return "OFF"
            time.sleep(0.1)
            serh.setDTR(True)
            serh.write (initstring+lterm)
            serh.read (1000)
            cal_state = CAL_ON
            cal_ontime = seconds+1
            x=serh.read (1000)

    if (cal_state == CAL_ON):
        cal_ontime -= 1
        if ((cal_ontime % 3) == 0):
            # send onstring
            serh.write (onstring+lterm)
            #sys.stderr.write( "in CAL_ON, send onstring")
            x=serh.read(100)
        if (cal_ontime &lt;= 0):
            t = int(time.time())
            #sys.stderr.write( "transitioning to OFF at %d\n" % t)
            # send offstring
            serh.setDTR(False)
            serh.write (offstring+lterm)
            x=serh.read(1000)
            cal_state = CAL_WAITING
            time.sleep(0.1)
            serh.write(offstring+lterm)
            time.sleep(0.1)
            x=serh.read(1000)
            time.sleep(0.1)
            serh.close()
            serh = None

    if (cal_state == CAL_ON):
        return "ON"

    return "OFF"

def calib_onoff_manual (control,devname,baudrate,onstring,offstring,lterm):
    global serh
    global cal_state
    global CAL_MANUAL
    global CAL_WAITING

    if (len(devname) == 0 or devname == "none"):
        return False

    if (cal_state == CAL_INIT_REQUIRED or cal_state == CAL_BADDEVICE):
        return False

    if (control == True):
        serh.write(onstring+lterm)
        x=serh.read (100)
        cal_state = CAL_MANUAL

    if (control == False):
        serh.write(offstring+lterm)
        x=serh.read(100)
        cal_state = CAL_WAITING

    return True


       
correction_counter = 0
corrections = [-1.0]*2
running_avgs = [0.0]*2
def update_corrections(l):
    global correction_counter
    global corrections
    global running_avgs
    
    a = 0.1
    
    if running_avgs[0] == 0.0 and running_avgs[1] == 0.0:
        running_avgs[0] = l[0]
        running_avgs[1] = l[1]
    
    running_avgs[0] = a*l[0] + ((1.0 - a)*running_avgs[0])
    running_avgs[1] = a*l[1] + ((1.0 - a)*running_avgs[1])
    
    correction_counter += 1
    
    if (correction_counter &lt; 180):
        return [1.0,1.0]
    
    if (corrections[0] &lt; 0.0):
        ratio = running_avgs[1]/(running_avgs[0]*0.97)
        corrections[0] = 1.0
        corrections[1] = 1.0/ratio

    return (corrections)

def map_udev(d):
    if '@' not in d:
        return (d)
    fn = d.strip("@")+".dprof"
    try:
        f = open (fn, "r")
    except:
        return (d)
    d = f.read()
    d = d.strip("\n")
    f.close()
    return (d)

    
</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0/(frate)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udev</value></param>
<param><key>label</key><value>UHD Device string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"None"</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blks2_tcp_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
