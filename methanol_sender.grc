<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>methanol_sender</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Methanol line spectrometer</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LO</value></param>
<param><key>value</key><value>(line_freq-if_freq)-tone_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_rate</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_freq</value></param>
<param><key>value</key><value>dfreq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>line_freq</value></param>
<param><key>value</key><value>freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(srate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tone_freq</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.75</value></param>
<param><key>freq</key><value>tone_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>addr</key><value>host</value></param>
<param><key>type</key><value>float</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>port+1</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_1</value></param>
<param><key>addr</key><value>host</value></param>
<param><key>type</key><value>float</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>port</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>int(fft_rate)/2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>256</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dfreq</value></param>
<param><key>label</key><value>Downconverted frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1353e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Center frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6.668518e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RF gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>host</value></param>
<param><key>label</key><value>Host to send to</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>127.0.0.1</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>1.0/(fft_rate*4)</value></param>
<param><key>average</key><value>True</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>frame_rate</key><value>fft_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>LO for external mixer</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Dummy data</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>Port to send to</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>14200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.8e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>txgain</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>LO</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>txgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>A:B</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(if_freq,samp_rate/1.5)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"master_clock_rate="+str(samp_rate*4)</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blks2_tcp_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
